# Keil uVision project example.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: example
  AfterMake: D:\Programe\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\example.bin  .\Objects\*.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT1: ROM 0x0 size 0x1000
  memory RVCT2: ROM 0x30000000 size 0x1000
  memory RVCT6: RAM 0x30001000 size 0x3fff000
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\Objects\example.sct
  group Source Group 1
    ./src/: start.S main.c
